# Keil uVision project Password_Based_doorLock_System_In_8051_Microcontroller_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: Password_Based_doorLock_System_In_8051_Microcontroller_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    E:/: Password_Based_doorLock_System_In_8051_Microcontroller_Project.c
